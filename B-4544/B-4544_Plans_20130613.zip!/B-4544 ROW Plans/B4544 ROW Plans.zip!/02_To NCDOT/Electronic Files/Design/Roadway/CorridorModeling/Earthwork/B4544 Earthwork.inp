XSECTION

Earthwork
 
tolerance = 0.10
 
vertical search distance = 500
 
xs dgn = R:\Roadway\CorridorModeling\B4544_Rdy_XSC.dgn

    Proposed Finish Grade
        soil type = Suitable
            type = line, line_string
            lvname = Prop CMT Conc Surface
            lvname = Prop CMT Pvmt Surface
            lvname = Prop CMT Slope Grass
            lvname = Prop CMT Subgrade Earthwork
            lvname = Prop CMT Pvmt Surface Shoulder
            lvname = Exist CMT Pavement
            
 
    Existing Ground Line
        soil type = Suitable
            type = line, line_string
            lvname = Exist XS Ground Line
            lvname = Exist XS Void Line
            lvname = Exist CMT Ground Line
 
    Write Earthwork Shapes
        plot param
            lvname = Prop XS Earthwork Shape
            Stratify Shape Color
 
    End Area Decimal Places = 2 
 
    Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 11+30.00	
        end sta = 13+79.84 

    Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 14+72.16
        end sta = 19+23.88 


    Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 20+06.13
        end sta = 22+00.00


   