HEC-RAS study B4544BLACKRIVER.prj: B4544 BLACK RIVER SR1722

--- B4544BLACKRIVER.g02 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,113597.7,718.6073,718.6073,718.6073
BEGIN DESCRIPTION:
Black River 126.0
END DESCRIPTION:
XS GIS Cut Line= 3
2104175.70095364614647.1480271292103663.11575978  612883.2201538
2101985.74876354610717.088205063
#Sta/Elev= 30
    3178  221.31  3210.7  215.81  3263.1  210.12  3319.7  206.43  3379.3  204.99
  3526.3  204.72  3535.1   205.9  3616.2  204.17  3831.7  204.94  3908.6  203.84
    4098   205.2  4223.9  203.89    4375  205.59  4554.2  205.82  4754.5  204.61
  4975.4  205.02    4984  203.99    4985  201.99    5015  201.99    5016  203.99
  5493.4  205.86  5925.5  205.63  5959.3  206.43  5987.4  210.29    6059  213.48
  6648.7  213.01  7129.5  214.22  7459.3  215.68  7690.9  218.71  7754.5  220.81
#Mann= 3 , 1 , 0
    3178     .15       0    4984    .045       0    5016     .15       0
Bank Sta=4984,5016
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,112879.1,693.807,693.807,693.807
BEGIN DESCRIPTION:
Black River 125.0
END DESCRIPTION:
XS GIS Cut Line= 3
2104432.32355392614827.6598561992104379.13301496612983.461169511
2103542.95454222610725.748292813
#Sta/Elev= 30
  3140.2  222.59  3163.9  221.85  3177.3   219.6  3436.8  207.39  3735.5  203.23
  3846.9  204.95    4151  203.64  4279.7   205.1    4370  203.15    4984  202.75
    4985  200.75    5015  200.75    5016  202.75  5047.3  203.91  5777.1  204.25
  5950.7  206.71  6410.3  208.01  6459.7  213.37  6494.2  213.47  6518.7  210.72
  6703.3  212.56  6871.3   211.4  6900.3  212.29  6921.7  210.34  7044.9  209.89
  7089.9  211.59  7197.3  211.35  7344.2  218.15  7351.1  220.93  7392.7   222.5
#Mann= 3 , 1 , 0
  3140.2     .15       0    4984    .045       0    5016     .15       0
Bank Sta=4984,5016
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,112185.3,885.609,885.609,885.609
BEGIN DESCRIPTION:
Black River 124.0
END DESCRIPTION:
XS GIS Cut Line= 3
 2104676.8960321 614556.787111532104894.66823871613317.124550418
2103629.29541709610737.348410354
#Sta/Elev= 30
  3750.2   218.1  4006.7  209.22  4157.3  207.54  4208.8  205.37  4346.1  203.61
  4377.1  204.66    4543  203.01  4834.8  203.37    4984  202.23    4985  200.23
    5015  200.23    5016  202.23  5171.6  203.42    5662  202.46  6164.6   205.4
  6444.6  204.72  6634.7  208.42  6743.5   207.4  7068.8  211.94  7175.5  211.64
  7271.2  209.04  7349.4  209.91  7395.5  209.07    7435  209.62  7458.1  211.25
  7473.7  209.57  7598.1  210.02    7640  212.12  7864.4  218.15  7882.2  220.67
#Mann= 3 , 1 , 0
  3750.2     .15       0    4984    .045       0    5016     .15       0
Bank Sta=4984,5016
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,111299.7,508.7052,508.7052,508.7052
BEGIN DESCRIPTION:
Black River 123.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106116.62062037 613525.516661992105547.68485553612824.509558904
2103740.13654021610616.367184489
#Sta/Elev= 30
  4100.9  221.29  4199.9  208.16    4273  203.35  4798.8  202.67  4821.5  204.09
  4887.5   202.3  4982.2  202.31  4983.7  199.31  5016.3  199.31  5017.8  202.31
  5757.8  202.97  5827.5  204.25  5893.9  203.05  5954.8   204.8  6041.3  204.51
  6099.9  206.93    6456  207.87  6850.5  211.08  6868.5  209.76  6975.4  209.89
  7039.1  208.04  7163.8  207.96  7208.2  210.49  7328.3  212.33  7554.7   210.1
  7631.5  211.17    7682  213.89  7732.1  213.91  7759.1  216.67  7857.3  221.34
#Mann= 5 , 1 , 0
  4100.9      10       0  4199.9     .15       0  4982.2    .045       0
  5017.8     .15       0  6099.9      10       0
Bank Sta=4982.2,5017.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,110791.0,578.5059,578.5059,578.5059
BEGIN DESCRIPTION:
Black River 122.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106192.38138803 613400.205392252105868.45810582612457.905844223
2103805.80720563610550.916521298
#Sta/Elev= 30
  4007.1  220.95  4133.1  210.89  4312.5  208.57  4359.9   205.5    4506  202.57
  4982.2  201.98  4983.7  198.98  5016.2  198.98  5017.7  201.98    5951  202.55
  6030.4  203.53  6099.9  205.98  6274.9  208.66    6647  208.38  6696.7  205.82
  6755.5  206.15  6765.2  207.49    6775  206.22  6817.6  206.22  6908.5   209.3
  7025.5  208.97  7057.9  210.18  7069.3  212.21    7162  210.72  7219.5  212.43
  7489.6  211.38  7514.6  213.06  7565.2   212.1  7640.2  212.89  7812.6  221.59
#Mann= 5 , 1 , 0
  4007.1      10       0  4359.9     .15       0  4982.2    .045       0
  5017.7     .15       0  6099.9      10       0
Bank Sta=4982.2,5017.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,110212.5,818.4083,818.4083,818.4083
BEGIN DESCRIPTION:
Black River 121.0
END DESCRIPTION:
XS GIS Cut Line= 3
2107643.13608808613058.8819337262106292.34240091612114.212361685
2103908.27824393 610483.00583318
#Sta/Elev= 30
  3346.6  220.81  3582.5  210.93  3719.9  207.01  3794.8   203.9  3972.8  202.19
  4982.2  202.06  4983.7  199.06  5016.3  199.06  5017.8  202.06  6127.1   202.3
  6151.3  204.41  6237.6  204.92  6299.9  207.07  6450.9  208.85  6527.2  208.42
  6632.6  207.29  6675.1   204.3  6699.2  204.16  6756.2   204.4  6777.9  206.33
  6841.2  208.56  6909.7  207.58  7016.4  210.24  7181.3  211.54  7508.3   210.4
  7516.3  211.74  7571.8  210.61  7747.5  214.45  7812.9  218.18  7883.6  220.53
#Mann= 5 , 1 , 0
  3346.6      10       0  3719.9     .15       0  4982.2    .045       0
  5017.8     .15       0  6299.9      10       0
Bank Sta=4982.2,5017.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,109394.1,826.4084,826.4084,826.4084
BEGIN DESCRIPTION:
Black River 120.0
END DESCRIPTION:
XS GIS Cut Line= 3
2108023.42994148612625.4475418712106647.48599947611392.465048446
 2103984.0890121610355.634542566
#Sta/Elev= 30
  3165.6  220.48  3237.4  213.97  3271.5  213.08  3296.7  209.55  3476.8  205.47
  3689.6  205.78  3803.6   202.4  3922.3     202    4155  203.02    4316  202.83
  4412.7  201.28  4982.2  200.84  4983.7  198.34  5016.3  198.34  5017.8  200.84
  5656.8  200.35  5898.8  203.08  6406.7  202.38    6507  200.82  6849.6  204.39
  6957.4   203.8  7115.5  206.67  7161.9  206.26  7237.7  209.25  7305.6  210.13
  7527.3  209.61  7585.2  211.76  7685.1   212.3  7720.2  215.22  7871.2  221.65
#Mann= 3 , 1 , 0
  3165.6     .15       0  4982.2    .045       0  5017.8     .15       0
Bank Sta=4982.2,5017.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,108567.7,891.109,891.109,891.109
BEGIN DESCRIPTION:
Black River 119.0
END DESCRIPTION:
XS GIS Cut Line= 3
2108088.68060264611987.3710764422107203.89163735610780.838851029
2104160.92080388610211.613083242
#Sta/Elev= 30
  3487.6  220.77  3506.1  218.53  3560.3  216.58  3614.9  212.32  3647.4  210.98
  3659.9  209.45  3695.3  208.89  3850.4  203.26  4210.9  203.01  4457.8  201.09
  4704.3  200.78  4793.4   201.7    4820  200.63  4981.3  200.35  4982.8  197.35
  5017.2  197.35  5018.7  200.35  5394.1  200.62  5494.6  199.83  5690.9  201.79
    6013  199.59  6294.1  200.28  7136.9  199.59  7380.1  202.19  7738.7  210.36
    7793  210.73    7818  211.93  7848.8  211.32  7870.8  212.79  8079.5  219.15
#Mann= 3 , 1 , 0
  3487.6     .15       0  4981.3    .045       0  5018.7     .15       0
Bank Sta=4981.3,5018.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,107676.6,631.0064,631.0064,631.0064
BEGIN DESCRIPTION:
Black River 118.0
END DESCRIPTION:
XS GIS Cut Line= 4
 2107290.8625186609811.1490254652107164.83124156 609908.41001098
2105706.44646421610155.8125178332104421.52344449610089.811849068
#Sta/Elev= 30
  4870.2  216.94  4877.9  216.69    4889  212.97  4911.6  208.03  4918.8  206.63
  4936.5  204.97  4955.8  200.79  4975.7  199.61  4981.3  200.01  4982.8  197.01
  5017.2  197.01  5018.7  200.01  5150.3  199.25  5172.2  199.81  5411.7   199.7
  5467.3  199.05  5583.4  199.85  5788.8  199.98  5810.4  199.42  5975.8  199.88
  6093.1  198.95  6470.9  199.98  7088.1   199.5  7211.6  201.22    7487  203.03
  7561.6  207.34  7745.1  214.86    7771  217.54  7783.3  217.27  7795.2  217.86
#Mann= 3 , 1 , 0
  4870.2     .15       0  4981.3    .045       0  5018.7     .15       0
Bank Sta=4981.3,5018.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,107045.6,70.0007,70.0007,70.0007
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
 2107694.5166087609129.642119969 2106651.5060402609623.057119589
2106175.63121831609836.7592849662105399.82335729609893.999864967
2104302.55223899609728.818191233
#Sta/Elev= 30
  3846.6  220.33  4026.6  215.42  4056.6   212.3  4086.6  212.52  4246.6  207.44
  4636.6  206.24  4666.6  202.19  4776.6  199.18    4980  200.05    4985   196.5
    5015   196.5    5020  200.05  5052.9  199.27  5122.9  199.53  5202.9  201.31
  5362.9  200.58  5402.9  201.35  5422.9   200.2  5482.9  199.97  5632.9  200.76
  5732.9  198.99  5952.9  200.57  6666.5  199.42    6970  203.25  7089.6  207.83
  7139.6  212.04  7179.6  213.69  7229.6  218.43  7289.6  217.84  7409.6  221.64
#Mann= 3 , 1 , 0
  3846.6     .15       0    4980     .05       0    5020     .15       0
#XS Ineff= 2 , 0
       0    4969   205.2    5031       0   205.2
Permanent Ineff=
       F       F
Bank Sta=4980,5020
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 2 ,107010.6,,,
BEGIN DESCRIPTION:
Ebenezer Church Road TOR
Structure ID: Ebenezer Church Road
Approximate Survey Structure
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,50,3,0, 60, 60, , , 0.95, 0, 1,1,,
  3846.6  3871.2  3901.2  3931.2  3951.2  4026.6  4056.6  4086.6  4156.6  4166.6
  4211.2  4226.6  4441.2  4636.6  4666.6  4696.6  4706.6  4776.6    4980    4985
    5015    5020  5052.9  5122.9  5202.9  5362.9  5402.9  5422.9  5522.1  5632.9
  5692.9  5742.1  5772.9  5832.9  5912.9  5976.5  5996.5  6072.1  6132.1    6600
  6666.5    6710    6750    6770    6830    6890    6970    7000    7020    7040
    7060  7089.6  7139.6  7179.6  7199.6  7229.6  7259.6  7289.6    7390  7409.6
  220.33   220.8  218.96  218.66  216.99  215.43  213.92  212.53  210.41  209.42
  209.12  207.89  208.34  207.13  207.01  206.89  206.65  206.37   205.2   205.2
   205.2   205.2   205.2  205.35     205  204.29  204.11  204.03  203.59  202.17
  201.41  200.78  201.28  201.38  201.52  201.62  201.65  201.78  200.66  200.32
  200.82  201.15   202.7  204.37  204.03  206.12  210.85  215.86  216.88  219.28
  218.41   218.8  219.45  219.98  220.24  220.63  221.02  221.42  222.73  221.64
  220.33  219.63  218.68  217.51  216.98  215.42   212.3  212.52   210.4  209.41
  208.66  207.88  206.84  206.24  202.19  201.08  201.52  199.18  200.05   196.5
   196.5  200.05  199.27  199.53  201.31  200.58  201.35   200.2  200.18  200.76
  199.34  199.31  199.95  199.04  200.47  199.85  200.59  200.27  200.24  199.53
  199.42  200.43   200.8  200.99  201.57  202.29  203.25  204.29     205  206.01
  206.55  207.83  212.04  213.69   216.2  218.43  217.51  217.84  221.02  221.64
  3846.6  3871.2  3901.2  3931.2  3951.2  4026.6  4056.6  4086.6  4156.6  4166.6
  4211.2  4226.6  4441.2  4636.6  4666.6  4696.6  4706.6  4776.6    4980    4985
    5015    5020  5052.9  5122.9  5202.9  5362.9  5402.9  5422.9  5522.1  5632.9
  5692.9  5742.1  5772.9  5832.9  5912.9  5976.5  5996.5  6072.1  6132.1    6600
  6666.5    6710    6750    6770    6830    6890    6970    7000    7020    7040
    7060  7089.6  7139.6  7179.6  7199.6  7229.6  7259.6  7289.6    7390  7409.6
  220.33   220.8  218.96  218.66  216.99  215.43  213.92  212.53  210.41  209.42
  209.12  207.89  208.34  207.13  207.01  206.89  206.65  206.37   205.2   205.2
   205.2   205.2   205.2  205.35     205  204.29  204.11  204.03  203.59  202.17
  201.41  200.78  201.28  201.38  201.52  201.62  201.65  201.78  200.66  200.32
  200.82  201.15   202.7  204.37  204.03  206.12  210.85  215.86  216.88  219.28
  218.41   218.8  219.45  219.98  220.24  220.63  221.02  221.42  222.73  221.64
  220.08  219.38  218.43  217.26  216.73  215.17  212.05  212.27  210.15  209.16
  208.41  207.63  206.59  205.99  201.94  200.83  201.27  198.93   199.8  196.25
  196.25   199.8  199.02  199.28  201.06  200.33   201.1  199.95  199.93  200.51
  199.09  199.06   199.7  198.79  200.22   199.6  200.34  200.02  199.99  199.28
  199.17  200.18  200.55  200.74  201.32  202.04     203  204.04  204.75  205.76
   206.3  207.58  211.79  213.44  215.95  218.18  217.26  217.59  220.77  221.39
BR Coef= 1 , 0 , 0 ,1.25, 0 ,,,0.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=1,3,,50,0.02,0.9,1,1,3,198.3,4998.05,197.85,4998.05,Culvert #1  , 0 ,10
Culvert Bottom n=0.02
Culvert=1,3,,50,0.02,0.9,1,1,3,198.1,5002.05,197.85,5002.05,Culvert #2  , 0 ,10
Culvert Bottom n=0.02
BR U #Sta/Elev= 154
  3846.6  220.33  3871.2  219.63  3881.2  219.35  3896.6  218.91  3901.2  218.68
  3916.6  217.89  3931.2  217.51  3951.2  216.98  3971.2  216.45  3981.2  216.19
  3991.2  215.93  4006.6  215.52  4016.6  215.64  4026.6  215.42  4036.6     214
  4046.6  213.57  4051.2  212.99  4056.6   212.3  4086.6  212.52  4091.2  212.36
  4111.2  211.64  4136.6  210.74  4146.6  210.75  4156.6   210.4  4161.2  209.94
  4166.6  209.41  4176.6  209.14  4186.6  209.32  4211.2  208.66  4216.6  208.52
  4221.2  208.23  4226.6  207.88  4246.6  207.44  4306.6  207.61  4326.6  207.19
  4401.2  206.96  4441.2  206.84  4541.2  206.53  4636.6  206.24  4656.6  203.95
  4666.6  202.19  4696.6  201.08  4701.2  201.28  4706.6  201.52  4711.2  201.25
  4726.6  200.36  4731.2   200.3  4746.6  200.08  4776.6  199.18  4926.6  199.76
  4936.6  200.25  4946.6  200.32  4961.2  199.94  4976.6  199.54    4980  200.05
    4985   196.5    5000   196.5    5015   196.5    5020  200.05  5032.9   199.9
  5052.9  199.27  5060.3   199.3  5060.5   199.3  5090.5  199.41  5122.9  199.53
  5202.9  201.31  5222.9  201.11  5362.9  200.58  5402.9  201.35  5412.9  201.28
  5422.9   200.2  5472.9  200.24  5482.9  199.97  5522.1  200.18  5632.9  200.76
  5662.9  199.94  5682.9  199.79  5692.9  199.34  5732.9  198.99  5742.1  199.31
  5752.1  199.65  5752.9  199.68  5772.9  199.95  5792.9  199.34  5802.9   199.5
  5832.9  199.04  5912.9  200.47  5922.9  200.03  5952.9  200.57  5956.5  200.53
  5966.5  200.53  5976.5  199.85  5986.5  199.94  5996.5  200.59  6016.5  200.08
  6046.5  200.24  6072.1  200.27  6082.1  200.28  6102.1   200.3  6112.1  200.31
  6126.5  200.32  6132.1  200.24  6166.5  199.74  6176.5  199.91  6272.1  199.69
  6296.5  199.64    6300   199.7    6310  199.87  6316.5  199.98    6330  199.96
    6600  199.53  6666.5  199.42  6676.5  200.11    6710  200.43    6720  200.52
    6750   200.8    6770  200.99  6779.6  201.08  6789.6  201.09    6830  201.57
    6850  201.81    6860  201.93    6880  202.17    6890  202.29    6910  202.53
    6920  202.65    6940  202.89    6950  203.01    6960  203.13  6969.6  203.24
    6970  203.25    6980   203.6    6990  203.95    7000  204.29  7019.6  204.97
    7020     205  7029.6  205.74    7040  206.01    7050  206.28  7059.6  206.53
    7060  206.55  7089.6  207.83  7109.6  209.87  7129.6  211.12  7139.6  212.04
  7179.6  213.69  7199.6   216.2  7209.6  216.67  7229.6  218.43  7249.6  217.65
  7259.6  217.51  7289.6  217.84    7390  221.02  7409.6  221.64
BR U #Mann= 3
  3846.6     .15    4980     .05    5020     .15
BR U Banks=4980,5020
BR D #Sta/Elev= 154
  3846.6  220.08  3871.2  219.38  3881.2   219.1  3896.6  218.66  3901.2  218.43
  3916.6  217.64  3931.2  217.26  3951.2  216.73  3971.2   216.2  3981.2  215.94
  3991.2  215.68  4006.6  215.27  4016.6  215.39  4026.6  215.17  4036.6  213.75
  4046.6  213.32  4051.2  212.74  4056.6  212.05  4086.6  212.27  4091.2  212.11
  4111.2  211.39  4136.6  210.49  4146.6   210.5  4156.6  210.15  4161.2  209.69
  4166.6  209.16  4176.6  208.89  4186.6  209.07  4211.2  208.41  4216.6  208.27
  4221.2  207.98  4226.6  207.63  4246.6  207.19  4306.6  207.36  4326.6  206.94
  4401.2  206.71  4441.2  206.59  4541.2  206.28  4636.6  205.99  4656.6   203.7
  4666.6  201.94  4696.6  200.83  4701.2  201.03  4706.6  201.27  4711.2     201
  4726.6  200.11  4731.2  200.05  4746.6  199.83  4776.6  198.93  4926.6  199.51
  4936.6     200  4946.6  200.07  4961.2  199.69  4976.6  199.29    4980   199.8
    4985  196.25    5000  196.25    5015  196.25    5020   199.8  5032.9  199.65
  5052.9  199.02  5060.3  199.05  5060.5  199.05  5090.5  199.16  5122.9  199.28
  5202.9  201.06  5222.9  200.86  5362.9  200.33  5402.9   201.1  5412.9  201.03
  5422.9  199.95  5472.9  199.99  5482.9  199.72  5522.1  199.93  5632.9  200.51
  5662.9  199.69  5682.9  199.54  5692.9  199.09  5732.9  198.74  5742.1  199.06
  5752.1   199.4  5752.9  199.43  5772.9   199.7  5792.9  199.09  5802.9  199.25
  5832.9  198.79  5912.9  200.22  5922.9  199.78  5952.9  200.32  5956.5  200.28
  5966.5  200.28  5976.5   199.6  5986.5  199.69  5996.5  200.34  6016.5  199.83
  6046.5  199.99  6072.1  200.02  6082.1  200.03  6102.1  200.05  6112.1  200.06
  6126.5  200.07  6132.1  199.99  6166.5  199.49  6176.5  199.66  6272.1  199.44
  6296.5  199.39    6300  199.45    6310  199.62  6316.5  199.73    6330  199.71
    6600  199.28  6666.5  199.17  6676.5  199.86    6710  200.18    6720  200.27
    6750  200.55    6770  200.74  6779.6  200.83  6789.6  200.84    6830  201.32
    6850  201.56    6860  201.68    6880  201.92    6890  202.04    6910  202.28
    6920   202.4    6940  202.64    6950  202.76    6960  202.88  6969.6  202.99
    6970     203    6980  203.35    6990   203.7    7000  204.04  7019.6  204.72
    7020  204.75  7029.6  205.49    7040  205.76    7050  206.03  7059.6  206.28
    7060   206.3  7089.6  207.58  7109.6  209.62  7129.6  210.87  7139.6  211.79
  7179.6  213.44  7199.6  215.95  7209.6  216.42  7229.6  218.18  7249.6   217.4
  7259.6  217.26  7289.6  217.59    7390  220.77  7409.6  221.39
BR D #Mann= 3
  3846.6     .15    4980     .05    5020     .15
BR D Banks=4980,5020
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=221.64
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,106975.6,1049.711,1049.711,1049.711
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 5
2107643.52609203609081.6816340012106600.50552343 609575.09663362
2106124.63070154609788.7987989972105348.82284052609846.039378998
2104251.56172232609680.857705264
#Sta/Elev= 30
  3846.6  220.09  4026.6  215.18  4056.6  212.06  4086.6  212.28  4246.6   207.2
  4636.6     206  4666.6  201.95  4776.6  198.94    4980  199.81    4985  196.26
    5015  196.26    5020  199.81  5052.9  199.03  5122.9  199.29  5202.9  201.07
  5362.9  200.34  5402.9  201.11  5422.9  199.96  5482.9  199.73  5632.9  200.52
  5732.9  198.75  5952.9  200.33  6666.5  199.18    6970  203.01  7089.6  207.59
  7139.6   211.8  7179.6  213.45  7229.6  218.19  7289.6   217.6  7409.6   221.4
#Mann= 3 , 1 , 0
  3846.6     .15       0    4980     .05       0    5020     .15       0
#XS Ineff= 2 , 0
       0    4969   204.5    5031       0   204.5
Permanent Ineff=
       F       F
Bank Sta=4980,5020
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,105925.9,820.8083,820.8083,820.8083
BEGIN DESCRIPTION:
Black River 114.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106930.23886451608824.4390274422105772.43713287608986.720671791
 2104615.9054141609358.464438554
#Sta/Elev= 30
  3818.3  221.83  3961.1  210.11  3985.8  207.47  4062.4  203.34  4134.7  202.39
  4158.5  205.22    4206  203.19  4260.6  202.79  4468.2  205.03  4526.1  206.99
  4559.9  206.58  4578.2  206.61  4603.4  205.08  4665.5  199.68  4981.4  199.37
  4982.9  196.37  5017.2  196.37  5018.7  199.37  5346.4  199.05  5616.7  199.94
  5651.8  201.91    5677  204.95  5749.9   206.7  5891.1  207.19  5964.7  209.16
  5978.3  211.23  6029.4  213.27  6064.7  216.27  6076.4   218.2  6202.2  221.75
#Mann= 5 , 1 , 0
  3818.3      10       0  4559.9     .13       0  4981.4    .044       0
  5018.7     .13       0  5749.9      10       0
Bank Sta=4981.4,5018.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,105105.1,949.8096,949.8096,949.8096
BEGIN DESCRIPTION:
Black River 113.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106926.68882854608703.0177971182105482.11419112608225.882962461
2104567.06491921608662.067382181
#Sta/Elev= 30
  3451.1  220.26  3457.6  219.09  3471.4  218.59  3527.1  213.25  3561.7  210.74
  3605.2  208.95  3683.9   209.3  3732.3  207.28  3868.5  205.52  3976.1  206.04
  4044.5   203.9  4197.1  204.77  4228.4  202.87  4267.5  199.25  4608.2  199.71
  4761.9  198.51    4837  199.12  4980.5  198.67    4982  195.67  5018.1  195.67
  5019.6  198.67  5381.9  199.36  5766.5  201.38  5796.4  202.05  5842.7  204.99
  5854.6  207.34  5881.2  209.25  5929.7  217.77  5964.8  218.59  5986.1  220.09
#Mann= 3 , 1 , 0
  3451.1     .13       0  4980.5    .044       0  5019.6     .13       0
Bank Sta=4980.5,5019.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,104155.3,634.0064,634.0064,634.0064
BEGIN DESCRIPTION:
Black River 112.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106788.19742525607773.1083746372105468.28405098607340.853994739
2104528.35452697608073.011413461
#Sta/Elev= 30
  3626.7  219.38  3692.5  208.76    3712  206.42  3750.7   204.2    3758  202.79
  3828.3  202.73  3921.1  200.65  3968.2  201.51  3995.2  199.96  4046.7  201.09
  4156.7  199.01  4181.1  199.67  4233.2  198.54  4275.8  199.13  4535.3  197.12
  4980.4  197.12  4981.9  194.12  5018.1  194.12  5019.6  197.12  5263.5  198.56
  5450.5  197.66  5775.3     199  5803.1  199.59  5828.2  204.24  5883.3   211.5
  5903.6  212.26  5929.9  215.39  5974.9  216.17  6112.7  215.58    6207  218.72
#Mann= 3 , 1 , 0
  3626.7     .13       0  4980.4    .044       0  5019.6     .13       0
Bank Sta=4980.4,5019.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,103521.3,591.506,591.506,591.506
BEGIN DESCRIPTION:
Black River 111.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106986.37943337606883.6393619262105468.28405098606718.557689205
 2104541.3346585606511.585592022
#Sta/Elev= 30
  3455.1  221.14  3612.2  216.03  3630.2  216.79    3639  215.38    3662  215.24
  3723.4  212.22  4076.3  205.58  4158.1  202.51  4405.9   199.5  4433.8  197.64
    4439  196.42  4609.8  197.46  4739.6  196.07  4980.3  196.77  4981.8  193.77
  5018.2  193.77  5019.7  196.77  5388.5  196.12  5413.6  197.19  5432.2  200.52
  5442.8  200.61  5467.6  203.78  5546.3  207.19  5591.1  210.54  5600.2   212.3
    5641  213.94  5658.4  216.09  5738.3  218.91  5827.8  218.74  5931.9  221.06
#Mann= 3 , 1 , 0
  3455.1     .13       0  4980.3    .044       0  5019.7     .13       0
Bank Sta=4980.3,5019.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,102929.8,868.0088,868.0088,868.0088
BEGIN DESCRIPTION:
Black River 110.0
END DESCRIPTION:
XS GIS Cut Line= 3
2106976.39933224606174.3821752452105576.14514391606136.371790098
2104686.27612714606229.712735893
#Sta/Elev= 30
    3579  220.57  3786.9  212.01  4227.7  204.03  4248.4   202.7  4444.2  202.89
  4498.6  200.22  4503.7  199.01  4559.3  197.18  4608.7  197.58  4640.5  196.31
  4683.9  197.49  4762.8   195.5  4948.2  198.04  4980.3  195.95  4981.8  192.95
  5018.3  192.95  5019.8  195.95  5147.8  198.75  5218.2  198.93  5231.9  198.88
  5245.5  195.93  5612.7  196.11  5657.6  203.17    5711  206.12  5744.8  210.32
    5771  210.87  5797.4  213.24  5821.1  217.03  5842.9  218.29  5874.5  218.01
#Mann= 3 , 1 , 0
    3579     .13       0  4980.3    .044       0  5019.8     .13       0
Bank Sta=4980.3,5019.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,102061.8,58.0006,58.0006,58.0006
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
2107603.14568287604871.778976375 2105737.9967839605313.233449495
2104325.42247072605641.006770719
#Sta/Elev= 30
  3071.6   211.1    3155  209.71  3299.4  203.34  3589.4  203.56  3669.4  201.07
  3719.4  196.82  3739.4  197.48  3789.4  194.68  3829.4   194.3  3869.4  196.28
  3949.4  195.01  4159.4  194.73  4189.4  195.95  4339.4  194.79  4629.4  197.26
  4839.4  195.04  4919.4  195.27  4977.5   197.6    4979   193.1    5021   193.1
  5022.5   197.6    5354  195.24    5894   196.2    5974  198.23    6054  203.56
    6144  207.11    6174  216.04    6314  216.74    6324  218.54  6438.3  218.24
#Mann= 3 , 1 , 0
  3071.6     .15       0  4977.5     .05       0  5022.5     .15       0
#XS Ineff= 2 , 0
       0    4973   203.5    5027       0   203.5
Permanent Ineff=
       F       F
Bank Sta=4977.5,5022.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 2 ,102032.8,,,
BEGIN DESCRIPTION:
NC-27 (Black River) TOR
Structure ID: NC Highway 27
Approximate Survey Structure
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
10,38,3,0, 60, 60, , , 0.95, 0, 1,1,,
  3071.6  3091.6    3155    3175  3299.4  3375.8  3509.4  3589.4  3669.4  3699.4
  3719.4  3739.4  3789.4  3829.4  3869.4  3889.4  3919.4  3949.4  4009.4  4159.4
  4189.4  4239.4  4339.4  4379.4  4409.4  4599.4  4629.4  4689.4  4819.4  4839.4
  4919.4  4929.4  4977.5    4979    5021  5022.5    5044    5084    5134    5174
    5224    5244    5314    5394    5444    5474    5494    5554    5614    5634
    5654    5844    5974    6054    6114    6144    6174    6314    6324  6438.3
   211.1  211.66  210.09  209.47  205.57   203.5  204.12  203.57   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5  204.18  206.19  208.06     209  216.05  216.75  218.55  218.24
   211.1  210.77  209.71  208.19  203.34  203.46  204.11  203.56  201.07  199.34
  196.82  197.48  194.68   194.3  196.28  195.48  196.13  195.01  195.97  194.73
  195.95  194.96  194.79  195.67  195.14  196.18  197.26  195.71  195.83  195.04
  195.27  196.36   197.6   193.1   193.1   197.6  198.07  196.73  197.41  195.75
   196.6  195.48   196.3  195.24  196.25  195.38  195.96  195.35  196.43  195.71
  196.38   195.7  198.23  203.56     205  207.11  216.04  216.74  218.54  218.24
  3071.6  3091.6    3155    3175  3299.4  3375.8  3509.4  3589.4  3669.4  3699.4
  3719.4  3739.4  3789.4  3829.4  3869.4  3889.4  3919.4  3949.4  4009.4  4159.4
  4189.4  4239.4  4339.4  4379.4  4409.4  4599.4  4629.4  4689.4  4819.4  4839.4
  4919.4  4929.4  4977.5    4979    5021  5022.5    5044    5084    5134    5174
    5224    5244    5314    5394    5444    5474    5494    5554    5614    5634
    5654    5844    5974    6054    6114    6144    6174    6314    6324  6438.3
   211.1  211.66  210.09  209.47  205.57   203.5  204.12  203.57   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5   203.5
   203.5   203.5  204.18  206.19  208.06     209  216.05  216.75  218.55  218.24
  210.91  210.58  209.52     208  203.15  203.27  203.92  203.37  200.88  199.15
  196.63  197.29  194.49  194.11  196.09  195.29  195.94  194.82  195.78  194.54
  195.76  194.77   194.6  195.48  194.95  195.99  197.07  195.52  195.64  194.85
  195.08  196.17  197.41  192.91  192.91  197.41  197.88  196.54  197.22  195.56
  196.41  195.29  196.11  195.05  196.06  195.19  195.77  195.16  196.24  195.52
  196.19  195.51  198.04  203.37  204.81  206.92  215.85  216.55  218.35  218.05
BR Coef= 1 , 0 , 0 ,1.25, 0 ,,,0.8,-1,2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
Culvert=2,10,10,38,0.015,0.4,1,8,1,193.3,4989.04,193.11,4989.04,Culvert #1  , 0 ,10
Culvert Bottom n=0.015
Culvert=2,10,10,38,0.015,0.4,1,8,1,193.3,5000.04,193.11,5000.04,Culvert #2  , 0 ,10
Culvert Bottom n=0.015
Culvert=2,10,10,38,0.015,0.4,1,8,1,193.3,5011.04,193.11,5011.04,Culvert #3  , 0 ,10
Culvert Bottom n=0.015
BR U #Sta/Elev= 113
  3071.6   211.1  3081.6  210.93  3091.6  210.77  3101.6   210.6  3121.6  210.27
  3141.6  209.93  3151.6  209.77    3155  209.71    3165  208.65    3175  208.19
    3195  207.89    3285  204.18  3289.4  204.13  3299.4  203.34  3351.6  203.42
  3361.6  203.43  3375.8  203.46  3489.4  203.63  3509.4  204.11  3589.4  203.56
  3609.4  202.82  3629.4  202.61  3669.4  201.07  3689.4  199.43  3699.4  199.34
  3719.4  196.82  3729.4  196.99  3739.4  197.48  3789.4  194.68  3829.4   194.3
  3849.4  195.78  3859.4  196.21  3869.4  196.28  3889.4  195.48  3919.4  196.13
  3939.4  195.18  3949.4  195.01  3959.4  195.67  4009.4  195.97  4019.4  195.78
  4029.4  195.31  4069.4  195.44  4079.4  194.91  4089.4  195.37  4099.4  195.49
  4159.4  194.73  4189.4  195.95  4239.4  194.96  4259.4   195.3  4279.4  194.76
  4329.4  195.11  4339.4  194.79  4349.4  195.31  4379.4  195.67  4409.4  195.14
  4569.4  196.35  4599.4  196.18  4629.4  197.26  4679.4  196.38  4689.4  195.71
  4779.4  195.53  4819.4  195.83  4839.4  195.04  4919.4  195.27  4929.4  196.36
  4977.5   197.6    4979   193.1    5000   193.1    5021   193.1  5022.5   197.6
    5044  198.07    5074  197.44    5084  196.73    5124  197.57    5134  197.41
    5164  195.96    5174  195.75    5224   196.6    5234  195.79    5244  195.48
    5314   196.3    5354  195.24    5394  195.24    5414  195.99    5444  196.25
    5454  196.07    5474  195.38    5494  195.96    5554  195.35    5614  196.43
    5634  195.71    5654  196.38    5744  195.96    5764  195.41    5824  196.26
    5844   195.7    5854  195.97    5894   196.2  5914.3  196.72    5974  198.23
  5998.3  199.66    6044  202.36    6054  203.56    6114     205    6144  207.11
    6164  213.55    6174  216.04  6308.3  216.71    6314  216.74  6318.3  217.51
    6324  218.54  6328.3  218.53  6438.3  218.24
BR U #Mann= 3
  3071.6     .15  4977.5     .05  5022.5     .15
BR U Banks=4977.5,5022.5
BR D #Sta/Elev= 113
  3071.6  210.91  3081.6  210.74  3091.6  210.58  3101.6  210.41  3121.6  210.08
  3141.6  209.74  3151.6  209.58    3155  209.52    3165  208.46    3175     208
    3195   207.7    3285  203.99  3289.4  203.94  3299.4  203.15  3351.6  203.23
  3361.6  203.24  3375.8  203.27  3489.4  203.44  3509.4  203.92  3589.4  203.37
  3609.4  202.63  3629.4  202.42  3669.4  200.88  3689.4  199.24  3699.4  199.15
  3719.4  196.63  3729.4   196.8  3739.4  197.29  3789.4  194.49  3829.4  194.11
  3849.4  195.59  3859.4  196.02  3869.4  196.09  3889.4  195.29  3919.4  195.94
  3939.4  194.99  3949.4  194.82  3959.4  195.48  4009.4  195.78  4019.4  195.59
  4029.4  195.12  4069.4  195.25  4079.4  194.72  4089.4  195.18  4099.4   195.3
  4159.4  194.54  4189.4  195.76  4239.4  194.77  4259.4  195.11  4279.4  194.57
  4329.4  194.92  4339.4   194.6  4349.4  195.12  4379.4  195.48  4409.4  194.95
  4569.4  196.16  4599.4  195.99  4629.4  197.07  4679.4  196.19  4689.4  195.52
  4779.4  195.34  4819.4  195.64  4839.4  194.85  4919.4  195.08  4929.4  196.17
  4977.5  197.41    4979  192.91    5000  192.91    5021  192.91  5022.5  197.41
    5044  197.88    5074  197.25    5084  196.54    5124  197.38    5134  197.22
    5164  195.77    5174  195.56    5224  196.41    5234   195.6    5244  195.29
    5314  196.11    5354  195.05    5394  195.05    5414   195.8    5444  196.06
    5454  195.88    5474  195.19    5494  195.77    5554  195.16    5614  196.24
    5634  195.52    5654  196.19    5744  195.77    5764  195.22    5824  196.07
    5844  195.51    5854  195.78    5894  196.01  5914.3  196.53    5974  198.04
  5998.3  199.47    6044  202.17    6054  203.37    6114  204.81    6144  206.92
    6164  213.36    6174  215.85  6308.3  216.52    6314  216.55  6318.3  217.32
    6324  218.35  6328.3  218.34  6438.3  218.05
BR D #Mann= 3
  3071.6     .15  4977.5     .05  5022.5     .15
BR D Banks=4977.5,5022.5
BC Design=,, 0 ,, 0 ,,,,,,
BC HTab HWMax=218.54
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,102003.8,678.7069,678.7069,678.7069
BEGIN DESCRIPTION:
Downstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 3
2107611.34576596 604814.358394552105746.19686699 605255.81286767
2104333.62255381605583.586188894
#Sta/Elev= 30
  3071.6  210.85    3155  209.46  3299.4  203.09  3589.4  203.31  3669.4  200.82
  3719.4  196.57  3739.4  197.23  3789.4  194.43  3829.4  194.05  3869.4  196.03
  3949.4  194.76  4159.4  194.48  4189.4   195.7  4339.4  194.54  4629.4  197.01
  4839.4  194.79  4919.4  195.02  4977.5  197.35    4979  192.85    5021  192.85
  5022.5  197.35    5354  194.99    5894  195.95    5974  197.98    6054  203.31
    6144  206.86    6174  215.79    6314  216.49    6324  218.29  6438.3  217.99
#Mann= 3 , 1 , 0
  3071.6     .15       0  4977.5     .05       0  5022.5     .15       0
#XS Ineff= 2 , 0
       0    4973   198.9    5027       0   198.9
Permanent Ineff=
       F       F
Bank Sta=4977.5,5022.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,101325.1,829.2084,829.2084,829.2084
BEGIN DESCRIPTION:
Black River 109.0
END DESCRIPTION:
XS GIS Cut Line= 3
2107570.58535294604775.0679964332105797.31738498604682.147054894
2104972.40902644605042.860709892
#Sta/Elev= 30
  3393.5  212.75  3444.5  210.36  3454.6  206.47  3468.2  202.95  3487.1  200.78
  3722.7  194.58  4166.1  194.34  4316.9  195.38  4327.2  196.48  4372.7  195.83
    4398  196.84  4450.5   195.7  4980.3   194.6  4981.8   191.6  5018.3   191.6
  5019.8   194.6  5415.2  195.83  5433.9  195.08  5494.5  196.84  5552.5  196.64
  5581.9  195.29    5601  196.41  5621.3  195.92  5652.2  197.77  5701.3  197.73
  5840.7  200.64  5903.4  203.25    5960  208.29  5994.4  209.79  6069.5  210.45
#Mann= 3 , 1 , 0
  3393.5     .15       0  4980.3    .046       0  5019.8     .15       0
Bank Sta=4980.3,5019.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,100495.9,766.3078,766.3078,766.3078
BEGIN DESCRIPTION:
Black River 108.0
END DESCRIPTION:
XS GIS Cut Line= 3
2108998.56982226603781.6979309252106271.62219096604052.530675188
2105214.20147644603273.372780225
#Sta/Elev= 30
  2253.5   214.2  2392.9  206.57  2446.8   205.6    2499  201.57  2558.1  200.51
  2583.8   201.6  2757.8  196.98  2767.2  198.08  2892.5  196.62  2917.1  193.29
  2942.6  194.36  3270.1  194.05  3294.4   195.2  3399.6  193.22  3511.9  195.43
  3946.3  193.41    4499  194.85  4979.7  194.16  4981.2  191.66  5018.9  191.66
  5020.4  194.16  5246.2  194.55  5435.4  197.85  5570.6  196.51  5870.4  199.01
  5928.2  200.19  5939.8  201.81  6035.8  205.37  6189.5  208.84  6307.3   214.1
#Mann= 3 , 1 , 0
  2253.5     .15       0  4979.7    .046       0  5020.4     .15       0
Bank Sta=4979.7,5020.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,99729.6 ,1058.311,1058.311,1058.311
BEGIN DESCRIPTION:
Black River 107.0
END DESCRIPTION:
XS GIS Cut Line= 3
2108892.94875204603651.0166067722106767.03721084603471.554788342
2105427.27363544602870.378696812
#Sta/Elev= 30
  2850.1  211.95  2933.1  204.88  3003.3  202.95  3021.5  201.22  3036.2  201.56
  3067.3  199.36  3127.2   197.5  3263.1  195.48  3515.7  194.34  3526.7   192.9
  3578.6  194.54  3656.7  194.68  3742.7  193.55  3949.7  193.38  4979.7  194.52
  4981.2  192.02  5018.8  192.02  5020.3  194.52  5145.8  195.47  5175.8  194.37
  5479.2  194.42  5537.8  197.16  5552.7   198.5  5556.9  200.46  5873.9  203.49
    5910  202.35  5991.3  202.61  6180.7  204.95  6365.4  207.86    6452  211.75
#Mann= 3 , 1 , 0
  2850.1     .15       0  4979.7    .046       0  5020.3     .15       0
Bank Sta=4979.7,5020.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,98671.3 ,929.9094,929.9094,929.9094
BEGIN DESCRIPTION:
Black River 106.0
END DESCRIPTION:
XS GIS Cut Line= 3
2108748.59728937603327.0333239512107401.28363746602772.257702583
2105789.85730938 601819.58804948
#Sta/Elev= 30
  3546.7  212.85  3846.9  202.28  3910.9  201.94  3998.5  204.96  4042.6  204.09
  4178.7  197.64    4296  194.14  4537.1  194.19  4678.6  192.46  4979.3  192.87
  4980.8  189.87  5019.3  189.87  5020.8  192.87  5563.2  192.87  5757.4  193.48
  5807.2  194.97  5920.9     193  5989.5  193.31  6005.1  194.65  6103.4  193.47
  6137.4   194.9    6162  193.96  6193.3  195.13  6224.6  193.73  6482.9   195.4
  6706.5  198.07  6772.4  201.96  6813.6  205.61  6853.9  211.43  6875.7  212.02
#Mann= 3 , 1 , 0
  3546.7     .15       0  4979.3    .046       0  5020.8     .15       0
Bank Sta=4979.3,5020.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,97741.4 ,935.4095,935.4095,935.4095
BEGIN DESCRIPTION:
Black River 105.0
END DESCRIPTION:
XS GIS Cut Line= 3
2109558.18549267602718.327156122 2108068.0603937602203.051934999
2105996.12939947601544.285259923
#Sta/Elev= 30
  3439.1  214.38  3520.3  208.97  3533.4  207.55  3549.9  203.71  3564.6  201.89
  3649.8  196.04  3691.8  194.93  3701.3  193.55  3875.5  192.44  3923.6  193.87
  4330.1  191.98  4979.3  191.99  4980.8  188.99  5019.2  188.99  5020.7  191.99
  6060.9  192.18  6379.3  194.38  6409.6  195.55  6468.2  194.93  6705.4  196.41
    6818   198.2  6892.7   197.5  6990.1  199.34  7039.5  202.93    7074  203.96
  7096.8  207.85  7100.2  209.25  7115.4  210.23  7131.4   212.5  7189.9  214.75
#Mann= 3 , 1 , 0
  3439.1     .15       0  4979.3    .046       0  5020.7     .15       0
Bank Sta=4979.3,5020.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,96806.0 ,790.208,790.208,790.208
BEGIN DESCRIPTION:
Black River 104.0
END DESCRIPTION:
XS GIS Cut Line= 3
2109324.62312606602281.9427343752108051.79022884601308.602871827
2106583.78535401600408.853754951
#Sta/Elev= 30
  3454.9  210.46  3488.8  206.95  3497.8   205.1  3559.4  197.51  3619.4  194.88
  3647.1  192.29  3941.6  192.47  4045.1  191.46  4073.4  192.18  4084.9  191.11
  4388.1  192.55  4843.9  190.84  4979.3  191.46  4980.8  188.96  5019.3  188.96
  5020.8  191.46  5460.5  192.46    5696  191.48  6073.5  196.72  6455.3  197.93
  6563.5  200.53  6574.4  202.31  6600.4  201.74  6620.4  203.94  6628.4  203.54
  6642.1  204.65  6692.1  204.79  6712.3  206.45  6762.2  208.26    6779  210.21
#Mann= 3 , 1 , 0
  3454.9     .15       0  4979.3    .046       0  5020.8     .15       0
Bank Sta=4979.3,5020.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,96015.8 ,895.7091,895.7091,895.7091
BEGIN DESCRIPTION:
Black River 103.0
END DESCRIPTION:
XS GIS Cut Line= 3
2109475.95465946602069.3905806512108848.66830336601162.241388792
2107565.54530187599792.277507377
#Sta/Elev= 30
  3851.7  209.13  3873.9  205.34  3896.3  203.81  3912.6  200.87  3960.2  198.99
  4004.8  195.67  4093.4  193.32  4251.7  191.79  4456.7   193.1  4629.6  190.14
  4729.1  191.06  4979.2  190.82  4980.7  188.32  5019.2  188.32  5020.7  190.82
  5081.7  190.86  5103.4  191.96    5162  192.12  5184.5  191.52  5544.1  192.25
  5687.7  191.52  6143.5  192.86  6262.2  195.98  6470.2  197.86    6748  205.56
  6777.3  205.79  6796.4  204.92  6807.4  205.82  6819.4  207.99  6831.6  208.81
#Mann= 3 , 1 , 0
  3851.7     .15       0  4979.2    .046       0  5020.7     .15       0
Bank Sta=4979.2,5020.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,95120.1 ,876.6089,876.6089,876.6089
BEGIN DESCRIPTION:
Black River 102.0
END DESCRIPTION:
XS GIS Cut Line= 3
2109906.08901787601891.9687828912109134.29119749600316.162815742
2108298.22272587599232.911839499
#Sta/Elev= 30
  3230.4  211.25    3241  209.48  3276.9  208.59  3286.1  206.06  3316.6  206.64
  3352.2  202.57  3394.6  202.31  3398.3  200.82  3411.4  200.78  3463.5  197.47
  3484.3  193.98  3572.6  193.92  3598.6  192.45  3679.8  191.13    3774  190.98
  3819.6  191.82  4013.9  190.86  4042.2  189.67  4049.6  190.96    4136  191.21
  4319.2  190.55  4979.2  191.16  4980.7  188.16  5019.2  188.16  5020.7  191.16
  5903.3  191.82  5998.2  193.89  6054.2  196.49  6147.8  202.88  6353.4  209.45
#Mann= 3 , 1 , 0
  3230.4     .15       0  4979.2    .046       0  5020.7     .15       0
Bank Sta=4979.2,5020.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,94243.5 ,978.2099,978.2099,978.2099
BEGIN DESCRIPTION:
Black River 101.0
END DESCRIPTION:
XS GIS Cut Line= 3
2110127.56126198601516.2249755972109743.11736653599714.846722795
2108986.26969763598459.814005941
#Sta/Elev= 30
  3126.4  210.67  3304.6  205.02  3395.7     203  3434.7   201.7  3453.6  200.44
  3485.2  200.06  3581.3  194.81  3692.6  191.87  4121.2  190.96    4134   191.7
  4238.6  190.48  4288.8  191.22  4396.5  190.54  4698.2  191.08  4720.9  190.43
  4766.9  191.09    4979  191.35    4981  187.35  5019.1  187.35  5021.1  191.35
  5424.1  190.89  5474.4  191.67  5528.1  191.23  5614.3  191.93  6288.9  191.07
  6305.6  192.34  6325.3  192.56  6355.1  197.03  6365.8  197.81  6433.9  210.17
#Mann= 3 , 1 , 0
  3126.4     .15       0    4979    .046       0  5021.1     .15       0
Bank Sta=4979,5021.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,93265.3 ,797.8081,797.8081,797.8081
BEGIN DESCRIPTION:
Black River 100.0
END DESCRIPTION:
XS GIS Cut Line= 3
2112544.16574868602109.0909829222110214.74214536598852.917989141
2109895.25890813597787.967198328
#Sta/Elev= 30
  1033.9   210.2  1133.4  205.97  1329.5  202.78  1794.4  198.31  2424.5  196.01
  2482.5  195.24  2549.4  195.69  2732.4  194.97  2772.7  193.51  2816.1  194.03
  3072.3  192.95  3095.9  192.27  3332.8   191.1  3853.8  190.25  3972.4  191.09
  4184.8  190.37  4778.5  190.58    4785  189.97  4858.9   190.4  4881.9  189.57
  4978.1  189.46  4980.1  185.96  5019.8  185.96  5021.8  189.46  5221.9  190.33
  5352.5  195.65  5424.6  202.37  5457.9     201  5579.2   204.6  6149.3  210.53
#Mann= 3 , 1 , 0
  1033.9     .15       0  4978.1    .046       0  5021.8     .15       0
Bank Sta=4978.1,5021.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,92467.5 ,638.3065,638.3065,638.3065
BEGIN DESCRIPTION:
Black River 99.0
END DESCRIPTION:
XS GIS Cut Line= 3
2112826.69861149601883.238694432 2110881.5189016598446.353869554
2110214.78214576597463.343909022
#Sta/Elev= 30
  1065.9  209.48  1153.3   209.1  1560.6   202.9  1591.5  203.45  2326.7  197.12
  2366.6  198.14  2409.3  196.56  2694.8  194.08  2809.3  193.66  2849.4  194.57
  2862.4  193.68  2890.1  193.44    2928  194.58  2951.5  194.49  3031.7  192.94
  3455.6  191.47    3715  189.48  3905.5  190.89  4105.1  189.38  4130.4  189.89
  4978.2  189.17  4980.2  185.17  5019.9  185.17  5021.9  189.17  5339.2   189.6
  5568.7  194.15  5746.9  196.42  5981.6  206.01  6093.9   207.9  6202.8  211.73
#Mann= 3 , 1 , 0
  1065.9     .14       0  4978.2    .044       0  5021.9     .14       0
Bank Sta=4978.2,5021.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,91829.2 ,931.2094,931.2094,931.2094
BEGIN DESCRIPTION:
Black River 98.0
END DESCRIPTION:
XS GIS Cut Line= 3
2113069.31106981600184.5614822672111509.25526225598291.852304038
2111040.89051646597377.693041148
#Sta/Elev= 30
  2524.3  207.27  2599.3  202.03  2679.7  198.49  2826.2  195.46    3390  192.68
  3450.3   190.3    3539  189.04  3759.2  188.88  3807.1  189.43  4270.1  188.64
  4977.8  188.79  4979.8  184.79  5020.3  184.79  5022.3  188.79  5056.9  189.42
  5073.4  188.94  5160.6  189.54  5184.7  188.88  5202.5  189.85  5206.1   190.8
    5243  192.08  5261.2  193.34  5271.4  194.73  5327.3  196.19  5362.1   196.3
  5406.1  195.43  5690.4  197.26  5831.7  200.84  5965.1  206.23  6004.2  208.69
#Mann= 3 , 1 , 0
  2524.3     .14       0  4977.8    .044       0  5022.3     .14       0
Bank Sta=4977.8,5022.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,90898.0 ,1156.112,1156.112,1156.112
BEGIN DESCRIPTION:
Black River 97.0
END DESCRIPTION:
XS GIS Cut Line= 3
2113103.48141605598599.9854262542111938.59961267597459.203867072
2111347.88362713596946.498671991
#Sta/Elev= 30
  3391.7  208.57  3522.3  205.24  3537.5  203.64  3604.8   201.8  3611.7  199.42
  3627.8  198.22  3635.1   196.6  3661.4  196.38  3684.5  193.05  3697.8  193.31
  3714.8  191.02  3762.6  188.34  3926.7  187.96  3950.2  188.93  3983.7  188.16
  4028.9  188.79    4364  187.49  4524.9  188.26  4686.7  187.38  4977.7  187.83
  4979.7  184.33  5020.2  184.33  5022.2  187.83  5266.6  187.83  5311.4  189.09
    5363  193.51  5412.9  196.16  5610.5  201.49  5789.4   207.2  5804.3  208.53
#Mann= 3 , 1 , 0
  3391.7     .14       0  4977.7    .044       0  5022.2     .14       0
Bank Sta=4977.7,5022.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,89741.9 ,807.4082,807.4082,807.4082
BEGIN DESCRIPTION:
Black River 96.0
END DESCRIPTION:
XS GIS Cut Line= 3
2113831.53879323599102.7905210212112875.32910425596769.656880108
2110954.87964494595799.537050188
#Sta/Elev= 30
  2427.3  221.56  3349.1  199.47  3404.8  197.17  3494.6  197.44  3540.4  196.48
  3583.5  194.63  3618.3  196.08  3692.8  197.93  3751.1  197.15  3878.5  189.73
  3955.2  188.68  4043.9   188.8  4427.9  186.61  4444.4  187.24  4527.8  187.37
  4606.7  186.72  4977.8  186.78  4979.8  182.78  5020.2  182.78  5022.2  186.78
  5131.7  187.57  5156.1   187.3  5295.8  189.25  5507.5  189.52  5574.3  191.83
  5763.5  195.18  6257.1  199.84  6837.3  213.07  6948.7  214.38  7100.3   218.1
#Mann= 3 , 1 , 0
  2427.3     .14       0  4977.8    .044       0  5022.2     .14       0
Bank Sta=4977.8,5022.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,88934.5 ,768.4078,768.4078,768.4078
BEGIN DESCRIPTION:
Black River 95.0
END DESCRIPTION:
XS GIS Cut Line= 3
 2114607.0366511598063.5999912292113541.45585391596357.232701143
2112464.59494241595335.002343203
#Sta/Elev= 30
  2966.2  207.25  3033.5  205.71  3143.1   198.4    3233  195.09  3295.1  194.03
  3318.5  191.71  3348.1  193.95  3389.5  191.01  3435.9  191.23  3654.2  188.29
  3985.4   186.7  4192.6  187.19  4540.1  186.21  4828.5  187.18  4977.2  186.46
  4979.2  182.46  5020.7  182.46  5022.7  186.46  5400.7  186.41  5509.6  188.72
  5527.4  190.66  5558.4  192.23    5614  193.05    5770  192.85    5839  191.33
  6098.3  195.32  6145.6  198.62  6186.2  199.22  6335.4  205.65  6462.7  208.67
#Mann= 3 , 1 , 0
  2966.2     .14       0  4977.2    .044       0  5022.7     .14       0
Bank Sta=4977.2,5022.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,88166.1 ,732.3574,732.3574,732.3574
BEGIN DESCRIPTION:
Black River 94.0
END DESCRIPTION:
XS GIS Cut Line= 3
2115531.32601664596929.1684963892114134.72186528595899.278060832
2112588.83620131594724.096153082
#Sta/Elev= 30
  3267.7   205.9  3394.6  202.31  3644.5  198.06  3696.6  195.61  3790.7   187.8
  3875.2   185.6  4665.9  185.45  4677.6  186.19  4916.9  186.51  4977.2  185.77
  4979.2  182.27  5020.7  182.27  5022.7  185.77  5288.4  186.61  5592.8  185.73
  5645.8  187.81  5682.1  191.93  5783.5   193.4  5922.5  191.97  6163.3  193.31
  6308.5  192.66  6475.8  196.41  6493.7  197.58  6513.9  196.78  6541.2   199.5
  6578.3  200.51  6605.4   198.5  6619.3   198.7  6813.6  204.79  6944.8  207.13
#Mann= 3 , 1 , 0
  3267.7     .14       0  4977.2    .044       0  5022.7     .14       0
Bank Sta=4977.2,5022.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,87433.8 ,44.5005,44.5005,44.5005
BEGIN DESCRIPTION:
Upstream Section of Bridge/Culvert/Weir
END DESCRIPTION:
XS GIS Cut Line= 6
2115793.50867325596621.6053799492115164.46229932595835.307412638
2114893.84955729595533.4743542582114009.15059291594940.208342879
2113748.94795636594367.7625424652113221.66261354593661.385384966
#Sta/Elev= 30
  3250.8  203.72    3278  202.51  3907.1  195.33  4005.7  193.39  4117.1  188.87
  4249.9  187.19  4308.2  185.47    4393  186.38    4953  185.52  4960.5  181.42
  5039.5  181.42    5047  185.52  5191.6  186.36  5390.6   185.6  5416.5   186.3
  5576.3  185.23  5691.6  186.99  5801.1  186.37  5809.2  185.56  5996.4  188.87
  6017.5  190.59  6675.5  196.19  6939.4  199.05    6998  200.21  7029.2  201.73
  7040.5  200.88  7061.4  201.16  7087.7  202.47  7127.2  201.83  7239.1  203.07
#Mann= 3 , 1 , 0
  3250.8     .15       0    4953     .05       0    5047     .15       0
#XS Ineff= 2 , 0
       0    4942     191    5058       0     191
Permanent Ineff=
       F       F
Bank Sta=4953,5047
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3
