HEC-RAS study B4544BLACKRIVER.prj: B4544 BLACK RIVER SR1722

--- B4544BLACKRIVER.g03 (geometry) --- (continued)

Type RM Length L Ch R = 4 ,71388   ,,,
BEGIN DESCRIPTION:
Three Bridge Road TOR
END DESCRIPTION:
Bridge Culvert--1,0,-1,-1, 0
Deck Dist Width WeirC Skew NumUp NumDn MinLoCord MaxHiCord MaxSubmerge Is_Ogee
35.7,33,2.6,0, 160, 162, , , 0.98, 0, 0,0,,
    31183163.4153183.1863202.9573222.7283242.4983262.269 3282.043301.8113321.582
3341.3533361.1243380.8953400.6663420.4373439.8913459.3443478.7983498.2513517.704
3537.1583556.6113576.0643595.5183614.9713634.4253653.878 3672.653691.4233710.195
3728.968 3747.743766.5123785.2853804.0573822.8293841.6023860.3743879.1463897.919
3916.6913936.0393955.3873974.7353994.0834013.4314032.7794052.1274071.4754090.823
4110.1714129.5194149.479 4169.444189.4014209.362    4225    4250    4275    4300
    4325    4350    4375    4400    4408    4408    4420    4420    4500    4500
    4512    4512    4525    4550    4575    4600    4625    4650    4675    4700
    4725    4750    4775    4800    4825    4850    4875    4900    49254941.421
4941.4214953.4214953.4215043.4215043.4215055.4215055.421    5075    5100    5125
    5150    5175    5200    5225    5250    52755586.649 5606.615626.5715646.531
5666.4925686.4535706.4145726.3745746.3355766.2955786.2565806.2175826.1785846.138
5866.099 5886.065906.0215925.9815945.9425965.9025985.8636005.8246025.7856045.745
6065.7066085.6676105.6276125.5886145.5496165.509 6185.476205.4316225.3926245.352
6265.3136285.2736305.2346325.1956345.1566365.1166385.0776405.0386424.9996444.959
 6464.92 6484.886504.8416524.8026544.7636564.7236584.6846604.6456624.6056644.566
     190 188.895 188.128 187.962 187.553 187.851 187.997 187.895  187.89 187.813
 187.498 187.118 186.861 186.611 186.363 186.252 186.024 185.827 185.357 185.138
 184.828 184.697 184.484 184.246 183.838 183.504 183.331 183.266 183.134 183.095
 182.768 182.405  182.22 182.099 181.991 181.886 181.702 181.549 181.355 181.117
 181.055 180.868 180.816 180.633  180.66  180.54 180.358  180.39 180.396 180.392
 180.454 180.559 180.626 180.702 180.655 180.732  180.61 181.019 181.429 181.838
 182.247 182.628 182.967 183.265   183.3  186.07  186.07  186.97  187.55  186.65
  186.65   184.1  184.14 184.192 184.202 184.172   184.1 183.987 183.847 183.737
  183.66  183.63  183.63  183.66  183.74  183.84  183.92  183.95 183.947   183.9
  186.49  186.49  187.39  186.88  185.98  185.98   183.5   183.1 182.875  182.65
 182.425   182.2 181.975  181.75 181.525   181.3 179.162 179.279 179.291 179.389
  179.48 179.621 179.978  180.41 180.774 181.216  181.64 181.985 182.114  182.35
 182.924  183.75   184.5 184.957 185.579 186.238 186.581 187.024  188.23 189.063
  189.66 190.394 190.939 191.372 192.743 194.605 194.951 196.173 197.392 197.801
 198.198 199.562 200.891 202.213 203.652 204.826 205.718 206.955 208.519 209.469
 210.702 212.063 212.836 213.954  215.21 215.558 216.668 217.475 218.326  218.31
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                          180.02  180.59
                                                                                
                                                                                
                  180.43  179.92
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
    31183163.4153183.1863202.9573222.7283242.4983262.269 3282.043301.8113321.582
3341.3533361.1243380.8953400.6663420.4373439.8913459.3443478.7983498.2513517.704
3537.1583556.6113576.0643595.5183614.9713634.4253653.878 3672.653691.4233710.195
3728.968 3747.743766.5123785.2853804.0573822.8293841.6023860.3743879.1463897.919
3916.6913936.0393955.3873974.7353994.0834013.4314032.7794052.1274071.4754090.823
4110.1714129.5194149.479 4169.444189.4014209.362    4225    4250    4275    4300
    4325    4350    4375    4400    4408    4408    4420    4420    4500    4500
    4512    4512    4525    4550    4575    4600    4625    4650    4675    4700
    4725    4750    4775    4800    4825    4850    4875    4900    49254932.579
4932.5794944.5794944.5795034.5795034.5795046.5795046.579    5075    5100    5125
    5150    5175    5200    5225    5250    52755586.649 5606.615626.5715646.531
5666.4925686.4535706.4145726.3745746.3355766.2955786.2565806.2175826.1785846.138
5866.099 5886.065906.0215925.9815945.9425965.9025985.8636005.8246025.7856045.745
6065.7066085.6676105.6276125.5886145.5496165.509 6185.476205.4316225.3926245.352
6265.3136285.2736305.2346325.1956345.1566365.1166385.0776405.0386424.9996444.959
 6464.92 6484.886504.8416524.8026544.7636564.7236584.6846604.6456624.6056644.566
6664.527 6669.94
     190 188.895 188.128 187.962 187.553 187.851 187.997 187.895  187.89 187.813
 187.498 187.118 186.861 186.611 186.363 186.252 186.024 185.827 185.357 185.138
 184.828 184.697 184.484 184.246 183.838 183.504 183.331 183.266 183.134 183.095
 182.768 182.405  182.22 182.099 181.991 181.886 181.702 181.549 181.355 181.117
 181.055 180.868 180.816 180.633  180.66  180.54 180.358  180.39 180.396 180.392
 180.454 180.559 180.626 180.702 180.655 180.732  180.61 181.019 181.429 181.838
 182.247 182.628 182.967 183.265   183.3  186.07  186.07  186.97  187.55  186.65
  186.65   184.1  184.14 184.192 184.202 184.172   184.1 183.987 183.847 183.737
 183.663 183.627 183.626 183.662 183.735 183.838 183.915 183.951 183.947   183.9
  186.49  186.49  187.39  186.88  185.98  185.98   183.5   183.1 182.875  182.65
 182.425   182.2 181.975  181.75 181.525   181.3 179.162 179.279 179.291 179.389
  179.48 179.621 179.978  180.41 180.774 181.216  181.64 181.985 182.114  182.35
 182.924  183.75   184.5 184.957 185.579 186.238 186.581 187.024  188.23 189.063
  189.66 190.394 190.939 191.372 192.743 194.605 194.951 196.173 197.392 197.801
 198.198 199.562 200.891 202.213 203.652 204.826 205.718 206.955 208.519 209.469
 210.702 212.063 212.836 213.954  215.21 215.558 216.668 217.475 218.326  218.31
 219.311     220
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                          180.02  180.59
                                                                                
                                                                                
                  180.43  179.92
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                                                                                
                
Abutment Skew #Up #Dn= , 5 , 5
    44204421.6254421.6254423.2254426.913
  180.02180.0316177.0316177.0316   171.5
    44204421.6254421.6254423.2254426.913
  180.02180.0316177.0316177.0316   171.5
Abutment Skew #Up #Dn= , 5 , 5
4492.0564496.7754498.3754498.375    4500
   170.5177.5784177.5784180.5784  180.59
4492.0564496.7754498.3754498.375    4500
   170.5177.5784177.5784180.5784  180.59
Abutment Skew #Up #Dn= , 5 , 5
 4953.424955.0464955.0464956.6464961.593
  180.43 180.421 177.421 177.421     170
4944.5794946.2044946.2044947.8044952.751
  180.43 180.421 177.421 177.421     170
Abutment Skew #Up #Dn= , 5 , 5
5037.5775040.1965041.7965041.7965043.421
     173 176.929 176.929 179.929  179.92
5028.7345031.3545032.9545032.954 5034.58
     173 176.929 176.929 179.929  179.92
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,0.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BR Coef= 1 , 1 , 0 ,1.25, 0 ,,,0.8,0,1.2,0,
WSPro=,,,, 1 ,,,, 0 ,,,, 0 ,,,,-1 ,-1 ,-1 , 0 , 0 , 0 , 0 , 0
BC Mult= 3 ,3118,4800,3140,4800
BC Mult= 3 ,4800,6690,4800,6690
BR U #Sta/Elev= 30
    3118     179    3721  177.54 3721.56  180.17 3936.55  174.34 4090.97  174.08
 4103.43  172.17  4387.8  172.28 4395.18   174.6 4432.68   174.6  4460.3  165.97
  4496.2   174.6 4517.75   174.6  4518.8  172.08 4529.33  171.87 4685.26  171.73
 4830.91  174.68 4970.64   174.6 4977.54  172.28  5008.3  170.53  5017.8  173.51
 5026.47     175 5271.16   179.1 5957.94   178.5  5961.5  183.25 5989.13  184.49
 6285.37  187.62 6369.59   190.2 6446.87  198.16 6591.26  202.54 6647.05  201.51
BR U #Mann= 5
    3118     .15 4432.68    .046  4496.2     .15 4977.54    .046  5017.8     .15
BR U Banks=4977.54,5017.8
BR D #Sta/Elev= 30
    3140     179    3788  176.24 3978.08  179.81    4028  173.67 4085.41  176.66
 4139.81  176.62 4177.83  173.11  4436.7   174.6  4451.2  168.36    4460  167.55
  4483.9   172.2  4491.1   174.6 4533.33   174.6 4547.15  172.47 4801.27  176.28
 4970.91     173  4982.5  169.37  5016.4     175  5089.1     175 5099.81  178.47
 5155.27  178.86  5570.8  176.43 5836.32     179 5839.44  181.56 5871.82   182.3
 6140.19  184.51  6235.1   187.7 6295.33  185.39 6468.15  193.31 6669.94  198.53
BR D #Mann= 5
    3140     .15  4436.7    .046  4483.9     .15 4970.91    .046  5016.4     .15
BR D Banks=4970.91,5016.4
BC Design=,, 0 ,, 0 ,,,,,,
BC Use User HTab Curves=0
BC User HTab FreeFlow(D)= 0

Type RM Length L Ch R = 1 ,71321   ,666.1,666.1,666.1
XS GIS Cut Line= 6
2113417.59376204581853.6701990072111477.28104162581602.232053578
2111198.36985403581548.0034874982110948.56786022581589.633653581
2110542.65627044581756.1648165882110126.31753621582182.899199337
#Sta/Elev= 30
    3140  202.38    3788  176.24 3978.08  179.81    4028  173.67 4085.41  176.66
 4139.81  176.62 4177.83  173.11  4436.7  174.68 4477.87  172.22 4533.33  174.25
 4547.15  172.47 4556.37  173.92 4755.91  174.68 4801.27  176.28 4943.86  173.09
 5015.14  173.38 5042.58  175.85 5104.35  178.72 5155.27  178.86 5275.98  177.55
 5398.86  178.64  5570.8  176.43 5812.54  183.22 5852.43  181.18 5917.35  181.25
 6252.39  187.82 6266.47  185.83 6295.33  185.39 6468.15  193.31 6669.94  198.53
#Mann= 5 ,-1 , 0
    3140     .15       0  4436.7    .046       0 4533.33     .15       0
 4943.86    .046       0 5042.58     .15       0
#XS Ineff= 3 ,-1
    3140 4394.85     180 4525.15 4919.43     183 5059.73    6661   178.5
Permanent Ineff=
       F       F       F
Bank Sta=4943.86,5042.58
XS Rating Curve= 0 ,0
Exp/Cntr=0.5,0.3

Type RM Length L Ch R = 1 ,70654.9 ,638.3065,638.3065,638.3065
BEGIN DESCRIPTION:
Black River 65.0
END DESCRIPTION:
XS GIS Cut Line= 3
2113148.02186736581105.6981621182111834.51855804 581005.17714357
2110233.34233383581503.702194968
#Sta/Elev= 30
  3711.4  189.31  3770.3  179.77  3854.8  173.97  4351.5  173.22  4397.8  174.43
  4602.9  174.28  4612.7  173.33  4630.3  174.47  4687.7  174.12  4715.2  175.22
  4745.4     174  4974.9  173.65  4976.9  169.65  5023.1  169.65  5025.1  173.65
  5042.2  174.84    5218  172.68  5270.4  174.31  5339.7  173.18  5418.3  175.95
  5505.3  175.06  5703.6  176.88  5817.4  176.03  5842.1  176.33  5857.9  178.01
  5928.1  177.74  5986.5  179.89  6179.5  179.75  6458.9  183.49  6705.7  189.76
#Mann= 3 ,-1 , 0
  3711.4     .15       0  4974.9    .046       0  5025.1     .15       0
#XS Ineff= 2 , 0
          4121.8     180  5403.2             178
Permanent Ineff=
       F       F
Bank Sta=4974.9,5025.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1
